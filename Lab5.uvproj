# Keil uVision project Lab5.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab5
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: DAC.c DAC.h main.c PLL.c PLL.h Sound.c Sound.h Speaker.c Speaker.h startup.s Switch.c Switch.h Time.c Time.h
